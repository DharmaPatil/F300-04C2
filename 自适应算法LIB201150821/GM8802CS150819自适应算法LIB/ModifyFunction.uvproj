# Keil uVision project ModifyFunction.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: ModifyFunction (library)
  c flags: Optim=1 wLevel=2
  group Source Group 1
    ./: Modify.c
