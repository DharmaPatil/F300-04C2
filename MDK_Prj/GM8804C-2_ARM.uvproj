# Keil uVision project GM8804C-2_ARM.uvproj, settings and files
target GM8804C-2_ARM (ARM-ADS)
  device: STR710FZ2 STMicroelectronics
  cpu: IROM (0x40000000-0x4003FFFF) IROM2(0x400C0000-0x400C3FFF) IRAM(0x20000000-0x2000FFFF) CLOCK(16000000) CPUTYPE(ARM7TDMI)
  output: GM8804C-2_ARM
  AfterMake: fromelf.exe --bin --output ./bin/GM8804C-2_ARM未合并BootLoader.bin ./output/GM8804C-2_ARM.axf
  c flags: Optim=4
  c include: ..\str71x\inc;..\str71x;..\Source
  memory RVCT4: ROM 0x40004000 size 0x3c000
  memory RVCT5: ROM 0x400c0000 size 0x4000
  memory RVCT9: RAM 0x20001000 size 0xf000
  link misc: --entry Reset_Handler
  group Source Code
    ../Source/: main.c
  group Function_Source
    ../Source/: Adaptation.c ADtoWeight.c BatchState.c CalibState.c DebugState.c DisplayAndKey.c IO.c Kalman.c MathLogic.c Modbus.c Parameter.c PrintState.c PROFIBUS_DP.c Recipe.c RunState.c StopAndRunState.c SetupState.c Sum.c ShutdownState.c TimeAndDate.c UART.c
  group Driver_Source
    ../Source/: AD.c Buzzer.c F_RAM.c RTC.c Timer.c UserLib.c VFD.c
  group STR71x_Interrupts
    ../str71x/: 71x_it.c
  group STR71x_Library
    ../str71x/src/: 71x_adc12.c 71x_apb.c 71x_bspi.c 71x_can.c 71x_eic.c 71x_emi.c 71x_gpio.c 71x_i2c.c 71x_lib.c 71x_pcu.c 71x_rccu.c 71x_rtc.c 71x_tim.c 71x_uart.c 71x_wdg.c 71x_xti.c
  group STR71x_Startup
    ../str71x/: STR71x.s
    ../str71x/ASM/: DAbt.s FIQ.s IRQ.s PAbt.s SWI.s Undef.s
